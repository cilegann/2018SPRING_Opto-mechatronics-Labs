# IAR project PWM.ewp, settings and files
configuration PWM (ARM, debug)
  General.OGChipSelectEditMenu: STM32F303RE ST STM32F303RE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F303xE
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F3xx_HAL_Driver/Inc; ../Drivers/STM32F3xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F3xx/Include; ../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: PWM.out
  ILINK.IlinkIcfFile: stm32f303xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ./: 
  group Application/EWARM
    //Mac/Home/Desktop/2018SPRING_Opto-mechatronics-Labs/PWM//EWARM/: startup_stm32f303xe.s
  group Application/User
    ./: 
    ../Src/: stm32f3xx_it.c main.c stm32f3xx_hal_msp.c
  group Drivers
    ./: 
  group Drivers/STM32F3xx_HAL_Driver
    ./: 
    ../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal.c stm32f3xx_hal_tim.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_i2c_ex.c stm32f3xx_hal_rcc.c stm32f3xx_hal_cortex.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_dma.c stm32f3xx_hal_i2c.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_pwr.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_flash.c
  group Drivers/CMSIS
    ./: 
    ../Src/: system_stm32f3xx.c
